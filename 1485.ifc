Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-07-18T12:20:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 18 12:20:50 2019 * Host: DESKTOP-23GQEAI * Database: C:\Users\vladb\AppData\Local\Temp\{7258A7A7-62A0-428D-9CA2-1FC3AA7BFB4D}\ifc * Database version: 5507 * Database creation date: Thu Jul 18 12:20:49 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jul 18 12:20:49 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jul 18 12:20:49 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1485 Cover part for shower faucet, 1485:1485 Cover part for shower faucet:322924
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions - NominalDepth: 93.5 mm; NominalHeight: 146.5 mm; NominalWidth: 130 mm
Type - General - Author: Convergo AB; BIMObjectName: 1485; ConvergoRefNr: 0087-1909-0048-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 17/07/2019
Type - Green Building Properties - Customs Code: 84819000; EAN Number: 6414150089282; EN Standard: EN 817
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/1485; Catalog Drawing URL: http://static.oras.com/catdrw/1485; Class: Single lever, trim kit; Dimension Drawing URL: http://static.oras.com/dimdrw/1485; FDV Document URL: http://www.oras.com/datasheet/1485/en/fdv; Group: Shower faucets; Long Marketing: Cover part for shower faucet. Round rosette Ø 130mm. For Oras concealed body 1486.; Manufacturer: Oras; Market: LTU;LVA;UKR; Model: 1485 Cover part for shower faucet; Name_en: 1485 Cover part for shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 210 x 165 x 60; Package Weight: 0.475 kg; Product Code: 1485; Product Datasheet: http://www.oras.com/datasheet/1485/en; Product Family: Oras Polara; Product Image URL: http://static.oras.com/image/1485; Product URL: http://static.oras.com/1485; Type Name: 1485 Cover part for shower faucet
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Installation and Maintenance: http://static.oras.com/manual/1485; Installation Type: Wall mounted for concealed unit; Lever Handle: Single operating lever; Max. Hot Water Supply: 80 kg/K/s3; Spare Parts: http://static.oras.com/sp/1485
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1485; Features: Trim Kit; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1485; Name: 1485 Cover part for shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 130x95x145 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1485; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1485 Cover part for shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.0448955 m2; Volume: 0.0017806 m3
Identity Data - Mark: 3
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1485: 1485 Cover part for shower faucet; Family and Type: 1485: 1485 Cover part for shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1485: 1485 Cover part for shower faucet; Type Id: 1485: 1485 Cover part for shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
